<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\driverlib\driverlib.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\CMSIS\RTOS2\RTX\Library\IAR\IDE\RTX_CM.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\tarefas\tarefas.ewp</path>
    </project>
    <batchBuild />
</workspace>
